# Keil uVision project edgeTrigIntr.uvproj, settings and files
target edgeTrigIntr (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: edgeTrigIntr
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s edgeTrigIntr.c weather.c
  group Dependencies
    ./driverlib/: gpio.c sysctl.c uart.c adc.c interrupt.c cpu.c
    ./utils/: uartstdio.c
